# Keil uVision project p6_7seg.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8032 (all Variants) Generic
  cpu: IRAM(0-0xFF) CLOCK(12000000)
  output: p6_7seg +hex
  AfterMake: xc2 -h .\objects\p6_7seg.hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: p6_7seg.asm
