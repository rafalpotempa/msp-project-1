# Keil uVision project p3_johnson_tab.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8032 (all Variants) Generic
  cpu: IRAM(0-0xFF) CLOCK(12000000)
  output: p4_johnson_tab
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: p3_johnson_tab.asm
