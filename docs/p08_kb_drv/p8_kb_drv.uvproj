# Keil uVision project p8_kb_drv.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8032 (all Variants) Generic
  cpu: IRAM(0-0xFF) CLOCK(12000000)
  output: p8_kb_drv
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: p8_kb_drv.asm
