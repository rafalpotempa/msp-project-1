# Keil uVision project p4_tm_pool.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8032 (all Variants) Generic
  cpu: IRAM(0-0xFF) CLOCK(12000000)
  output: p4_tm_pool
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: p4_timer_pooling.asm
