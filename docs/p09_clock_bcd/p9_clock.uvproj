# Keil uVision project p9_clock.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8032 (all Variants) Generic
  cpu: IRAM(0-0xFF) CLOCK(12000000)
  output: p9_clock
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: p9_clock_bcd.asm
