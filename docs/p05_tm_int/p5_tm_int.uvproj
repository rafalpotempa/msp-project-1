# Keil uVision project p5_tm_int.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8032 (all Variants) Generic
  cpu: IRAM(0-0xFF) CLOCK(12000000)
  output: p5_tm_int
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: p5_timer_int.asm
