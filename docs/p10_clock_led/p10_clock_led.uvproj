# Keil uVision project p10_clock_led.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8032 (all Variants) Generic
  cpu: IRAM(0-0xFF) CLOCK(12000000)
  output: p10_clock_led
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: p10_clock_led.asm
