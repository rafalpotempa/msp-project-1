# Keil uVision project p7_7seg_mux.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8032 (all Variants) Generic
  cpu: IRAM(0-0xFF) CLOCK(12000000)
  output: p7_7seg_mux +hex
  AfterMake: xc2 -h .\objects\p7_7seg_mux.hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: p7_7seg_mux.asm
